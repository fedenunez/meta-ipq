
FILESEXTRAPATHS_append := "${THISDIR}/files:"
SRC_URI += "file://001-remove_shared_mount_229.patch"
