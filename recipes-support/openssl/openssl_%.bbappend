FILESEXTRAPATHS_append := "${THISDIR}/files:"
EXTRA_OECONF_remove= "no-md4"
